# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f407
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_USED=1U,__FPU_PRESENT=1U
  c include: ..;  ../../..;  ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c i2c.c iwdg.c spi.c sys.c stm32f4xx_hal_timebase_tim.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group interface
    ../../../interface/: robot.cpp callback.cpp
    ../: hardware_config.h
  group lib/arm_math
    ../../../lib/arm_math/: arm_cortexM4lf_math.lib
  group base
    ../../../base/bsp_buzzer/: bsp_buzzer.cpp
    ../../../base/bsp_led/: bsp_led.cpp
    ../../../base/encoder/: encoder.cpp
    ../../../base/monitor/: can_monitor.cpp motor_monitor.cpp imu_monitor.cpp
    ../../../base/motor/motor_driver/: dji_motor_driver.cpp lk_motor_driver.cpp mit_motor_driver.cpp
    ../../../base/motor/: motor.cpp swerve_steering_motor.cpp
    ../../../base/remote/: remote.cpp wfly.cpp
    ../../../base/servo/: servo.cpp
    ../../../base/tof/: tof.cpp
    ../../../base/imu/: imu.cpp mahony.cpp
    ../../../base/imu/driver/: bmi088.cpp mpu6500.cpp ist8310.cpp
  group common
    ../../../common/bool_input/: bool_input.cpp
    ../../../common/connect/: connect.cpp
    ../../../common/log/: bsp_log.c
    ../../../common/message_center/: message_center.cpp
    ../../../common/power_limit/: power_limit.cpp
    ../../../common/communication/cv_comm/: cv_comm.cpp
    ../../../common/communication/referee_comm/: referee_comm.cpp referee_ui.cpp
    ../../../common/communication/cap_comm/: cap_comm.cpp
    ../../../common/communication/board_comm/: board_comm.cpp
  group app
    ../../../app/chassis/: chassis.cpp MecanumChassis.cpp SwerveChassis.cpp
    ../../../app/control/: control.cpp
    ../../../app/shoot/: shoot.cpp
    ../../../app/motorinit/: motorinit.cpp
    ../../../app/gimbal/: gimbal.cpp
    ../../../app/demo_arm/: arm.cpp rc_to_theta.cpp
  group algorithm
    ../../../algorithm/crc/: crc.cpp
    ../../../algorithm/fifo_buffer/: fifo_buffer.cpp
    ../../../algorithm/filter/: filter.cpp kalman_filter.cpp
    ../../../algorithm/pid/: pid.cpp
    ../../../algorithm/math/: math.cpp matrix.cpp
  group SEGGER
    ../../../middleware/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.1.2
